# Autodesk Inventor part: D171AEXS-PF-35MM
## iProperties
Created: 2012-01
Part Number: D171AEXS-PF-35MM
Document SubType Name: Modeling
Designer: D Cole
Density: 1 g/cm^3
Author: D Cole
